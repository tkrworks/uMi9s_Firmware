# IAR project uMi9s.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFR32BG1B232F256GM56 SiliconLaboratories EFR32BG1B232F256GM56
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: GENERATION_DONE; EFR32BG1B232F256GM56; SILABS_AF_USE_HWCONF; HAL_CONFIG
  ICCARM.IExtraOptions: --enum_is_int; --macro_positions_in_diagnostics
  ICCARM.CCIncludePath2: inc; $PROJ_DIR$; C:\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.1\protocol\bluetooth_2.7\ble_stack\inc\common; C:\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.1\protocol\bluetooth_2.7\ble_stack\inc\soc; C:\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.1\platform\bootloader\api; C:\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.1\platform\emdrv\dmadrv\inc; C:\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.1\platform\emlib\inc; C:\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.1\platform\CMSIS\Include; C:\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.1\platform\Device\SiliconLabs\EFR32BG1B\Include; C:\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.1\platform\emdrv\common\inc; C:\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.1\platform\emdrv\dmadrv\config; C:\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.1\platform\emdrv\gpiointerrupt\inc; C:\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.1\platform\emdrv\nvm\config; C:\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.1\platform\emdrv\nvm\inc; C:\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.1\platform\emdrv\rtcdrv\config; C:\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.1\platform\emdrv\rtcdrv\inc; C:\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.1\platform\emdrv\sleep\inc; C:\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.1\platform\emdrv\spidrv\config; C:\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.1\platform\emdrv\spidrv\inc; C:\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.1\platform\emdrv\tempdrv\config; C:\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.1\platform\emdrv\tempdrv\inc; C:\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.1\platform\emdrv\uartdrv\config; C:\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.1\platform\emdrv\uartdrv\inc; C:\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.1\platform\emdrv\ustimer\config; C:\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.1\platform\emdrv\ustimer\inc; C:\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.1\hardware\kit\EFR32BG1_BRD4301A\config; C:\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.1\hardware\kit\common\bsp; C:\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.1\hardware\kit\common\drivers; C:\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.1\platform\radio\rail_lib\chip\efr32\rf\common\cortex; C:\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.1\platform\radio\rail_lib\common; C:\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.1\platform\radio\rail_lib\chip\efr32; C:\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.1\platform\halconfig\inc\hal-config; C:\SiliconLabs\SimplicityStudio\v4\developer\sdks\gecko_sdk_suite\v2.1\hardware\kit\common\halconfig; hal-config
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: uMi9s.bin
  ILINK.IlinkOutputFile: uMi9s.out
  ILINK.IlinkKeepSymbols: __iar_program_start
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\SiliconLaboratories\EFR32BG1B232F256.icf
  ILINK.IlinkExtraOptions: --no_range_reservations
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: application_properties.c ble-configuration.h board_features.h create_bl_files.bat defines.h dmadrv_config.h efr32bg1b232f256gm56.ld gatt.xml gatt_db.c gatt_db.h hal-config-app-common.h hal-config-board.h hal-config.h init_app.c init_app.h init_board.c init_board.h init_mcu.c init_mcu.h main.c mpu9250.h SigmaStudioFW.c SigmaStudioFW.h uartdrv_config.h uMi9s.isc umi9s_IC_1.h umi9s_IC_1_PARAM.h umi9s_IC_1_REG.h
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.1/platform/Device/SiliconLabs/EFR32BG1B/Source/IAR/: startup_efr32bg1b.s
  group app/bluetooth_2.7/common/stack_bridge
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.1/app/bluetooth_2.7/common/stack_bridge/: infrastructure.h
  group hal-config
    hal-config/: hal-config.h
  group hardware/kit/common/bsp
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.1/hardware/kit/common/bsp/: bsp.h bsp_bcp.h bsp_stk.c
  group hardware/kit/common/drivers
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.1/hardware/kit/common/drivers/: i2cspm.c i2cspm.h udelay.c udelay.h
  group hardware/kit/common/halconfig
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.1/hardware/kit/common/halconfig/: bsphalconfig.h displayhalconfig.h i2cspmhalconfig.h mx25flashhalconfig.h retargetserialhalconfig.h tracehalconfig.h
  group platform/bootloader/api
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.1/platform/bootloader/api/: application_properties.h
  group platform/CMSIS/Include
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.1/platform/CMSIS/Include/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armcc_V6.h cmsis_gcc.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSimd.h core_sc000.h core_sc300.h
  group platform/Device/SiliconLabs/EFR32BG1B/Include
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.1/platform/Device/SiliconLabs/EFR32BG1B/Include/: efr32bg1b132f128gj43.h efr32bg1b132f128gm32.h efr32bg1b132f128gm48.h efr32bg1b132f256gd1.h efr32bg1b132f256gj43.h efr32bg1b132f256gm32.h efr32bg1b132f256gm48.h efr32bg1b132f256gm56.h efr32bg1b132f256im32.h efr32bg1b232f128gj43.h efr32bg1b232f128gm32.h efr32bg1b232f128gm48.h efr32bg1b232f256gj43.h efr32bg1b232f256gm32.h efr32bg1b232f256gm48.h efr32bg1b232f256gm56.h efr32bg1b232f256im32.h efr32bg1b_acmp.h efr32bg1b_adc.h efr32bg1b_af_pins.h efr32bg1b_af_ports.h efr32bg1b_cmu.h efr32bg1b_cryotimer.h efr32bg1b_crypto.h efr32bg1b_devinfo.h efr32bg1b_dma_descriptor.h efr32bg1b_dmareq.h efr32bg1b_emu.h efr32bg1b_fpueh.h efr32bg1b_gpcrc.h efr32bg1b_gpio.h efr32bg1b_gpio_p.h efr32bg1b_i2c.h efr32bg1b_idac.h efr32bg1b_ldma.h efr32bg1b_ldma_ch.h efr32bg1b_letimer.h efr32bg1b_leuart.h efr32bg1b_msc.h efr32bg1b_pcnt.h efr32bg1b_prs.h efr32bg1b_prs_ch.h efr32bg1b_prs_signals.h efr32bg1b_rmu.h efr32bg1b_romtable.h efr32bg1b_rtcc.h efr32bg1b_rtcc_cc.h efr32bg1b_rtcc_ret.h efr32bg1b_timer.h efr32bg1b_timer_cc.h efr32bg1b_usart.h efr32bg1b_wdog.h efr32bg1b_wdog_pch.h em_device.h system_efr32bg1b.h
  group platform/Device/SiliconLabs/EFR32BG1B/Source
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.1/platform/Device/SiliconLabs/EFR32BG1B/Source/: system_efr32bg1b.c
  group platform/emdrv/common/inc
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.1/platform/emdrv/common/inc/: ecode.h
  group platform/emdrv/dmadrv/inc
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.1/platform/emdrv/dmadrv/inc/: dmadrv.h
  group platform/emdrv/dmadrv/src
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.1/platform/emdrv/dmadrv/src/: dmadrv.c
  group platform/emdrv/gpiointerrupt/inc
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.1/platform/emdrv/gpiointerrupt/inc/: gpiointerrupt.h
  group platform/emdrv/gpiointerrupt/src
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.1/platform/emdrv/gpiointerrupt/src/: gpiointerrupt.c
  group platform/emdrv/sleep/inc
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.1/platform/emdrv/sleep/inc/: sleep.h
  group platform/emdrv/sleep/src
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.1/platform/emdrv/sleep/src/: sleep.c
  group platform/emdrv/tempdrv/inc
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.1/platform/emdrv/tempdrv/inc/: tempdrv.h
  group platform/emdrv/tempdrv/src
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.1/platform/emdrv/tempdrv/src/: tempdrv.c
  group platform/emdrv/uartdrv/inc
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.1/platform/emdrv/uartdrv/inc/: uartdrv.h
  group platform/emdrv/uartdrv/src
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.1/platform/emdrv/uartdrv/src/: uartdrv.c
  group platform/emlib/inc
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.1/platform/emlib/inc/: em_assert.h em_bus.h em_chip.h em_cmu.h em_common.h em_core.h em_cryotimer.h em_crypto.h em_emu.h em_gpcrc.h em_gpio.h em_i2c.h em_ldma.h em_leuart.h em_msc.h em_prs.h em_ramfunc.h em_rmu.h em_rtcc.h em_system.h em_usart.h
  group platform/emlib/src
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.1/platform/emlib/src/: em_cmu.c em_core.c em_cryotimer.c em_crypto.c em_emu.c em_gpio.c em_i2c.c em_ldma.c em_leuart.c em_msc.c em_rmu.c em_rtcc.c em_system.c em_usart.c
  group platform/halconfig/inc/hal-config
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.1/platform/halconfig/inc/hal-config/: hal-config-types.h
  group platform/radio/rail_lib/autogen/librail_release
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.1/platform/radio/rail_lib/autogen/librail_release/: librail_efr32xg1_iar_release.a
  group platform/radio/rail_lib/chip/efr32
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.1/platform/radio/rail_lib/chip/efr32/: rail_chip_specific.h
  group platform/radio/rail_lib/common
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.1/platform/radio/rail_lib/common/: rail.h rail_types.h
  group protocol/bluetooth_2.7/ble_stack/inc/common
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.1/protocol/bluetooth_2.7/ble_stack/inc/common/: bg_errorcodes.h bg_gattdb_def.h bg_types.h gecko_configuration.h
  group protocol/bluetooth_2.7/ble_stack/inc/soc
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.1/protocol/bluetooth_2.7/ble_stack/inc/soc/: bg_version.h native_gecko.h
  group protocol/bluetooth_2.7/lib/EFR32BG1B/IAR
    ../../../../../SiliconLabs/SimplicityStudio/v4/developer/sdks/gecko_sdk_suite/v2.1/protocol/bluetooth_2.7/lib/EFR32BG1B/IAR/: binapploader.o libbluetooth.a libmbedtls.a libpsstore.a
